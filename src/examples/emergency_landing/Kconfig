## src/examples/emergency_landing/Kconfig
```kconfig
menuconfig EXAMPLES_EMERGENCY_LANDING
	bool "emergency_landing"
	default n
	---help---
		Enable support for emergency_landing
```
